require conf/include/flutter-app.inc

inherit flutter-native-assets
