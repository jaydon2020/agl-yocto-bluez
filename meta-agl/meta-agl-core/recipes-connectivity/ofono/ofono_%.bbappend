# Keep oFono for cellular modems, but let PipeWire own Bluetooth HFP.
PACKAGECONFIG:remove = "bluez"
